# Keil uVision project base_project.uvprojx, settings and files
target TM4C129 RAM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: base_project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: TARGET_IS_TM4C129_RA0 PART_TM4C1294NCPDT
  c include: ..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Files
    ./: lab03.c
  group Documentation
    ./: Abstract.txt
  group drivers
    ./: buzzer.c accel.c buttons.c cfaf128x128x16.c led.c mic.c opt.c rgb.c servo.c joy.c temp.c utils.s
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
    ../grlib/rvmdk/: grlib.lib
  group Sprites
    ./GameSprites/Chefao/: Chefao.c
    ./GameSprites/Eddie/: Eddie.c
    ./GameSprites/Escada/: Escada.c
    ./GameSprites/Inimigo/: Inimigo.c
    ./GameSprites/Item/: Item.c
    ./GameSprites/Background/: Background.c
    ./GameSprites/Numeros/: Numeros.c
target TM4C129 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: base_project
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, Device:Startup 1.0.0
